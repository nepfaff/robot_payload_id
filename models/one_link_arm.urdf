Commit message: Add rotor inertia to one_link_arm model

File: models/one_link_arm.urdf (robot description, URDF)
Before this commit: robot one-link-arm, 2 links, 2 joints
Joints:
- removed joint shoulder
- added joint joint1: type continuous, parent base, child link1, axis 0 1 0
